require litesdcard.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=9f3746ccc6348e52617a7a527ae22ff8"

SRCREV = "15955d88ad2390dfa46f4846f7fc22bd642738db"
PV = "2022.12+git${SRCPV}"
