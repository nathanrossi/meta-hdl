require litesata.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=06961f9174ef2f11bff41b45f906eb5f"

SRCREV = "8cce117914487256454421039d7f3948970caa2f"
PV = "2024.08+git${SRCPV}"
