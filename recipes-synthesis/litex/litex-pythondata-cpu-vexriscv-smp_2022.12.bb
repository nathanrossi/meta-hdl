require litex-pythondata-cpu-vexriscv-smp.inc

SRCREV = "b360267b9b140790990bbb1b6bc75134b204ade1"
PV = "2022.12+git${SRCPV}"
