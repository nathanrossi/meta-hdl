require litepcie.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=26002bebf4fb75e22401233046399ea1"

SRCREV = "ce3db4ea31d9efc14073db5481612284a41d2b53"
PV = "2024.08+git${SRCPV}"
