require litex-pythondata-cpu-vexriscv.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=38aa75cf4c4c87f018227d5ec9638d75"

SRCREV = "e75700dff2ab9662f3e26dd89ab59a5f6da65687"
PV = "2022.12+git${SRCPV}"
