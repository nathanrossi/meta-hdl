require litex-boards.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=44c881049d568ad42c4c81ed51fa6515"

SRCREV = "f5643e7c78cae4f9c99a37c16e57ff57e179c5cb"
PV = "2022.12+git${SRCPV}"
