require litedram.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=f9889f63ba517bd604fde468a6b85bfd"

SRCREV = "ed81c8cc861ae14e44b2df83adce3ff39ca7f7ac"
PV = "2023.08+git${SRCPV}"
