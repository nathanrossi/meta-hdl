require litesdcard.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=9f3746ccc6348e52617a7a527ae22ff8"

SRCREV = "e018257aa2c5e5ac795c3e3b41ab256d150a4b52"
PV = "2023.08+git${SRCPV}"
