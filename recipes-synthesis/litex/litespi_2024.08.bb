require litespi.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=99cb24c95072af16a66df894e8b495b9"

SRCREV = "4f60633cbe744701bf552c5d5a1c404a71581e73"
PV = "2024.08+git${SRCPV}"
