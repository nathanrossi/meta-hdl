require litescope.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=c779474112984b3fbcfaba3dc8f3f3b4"

SRCREV = "7105b474026383fff6e3c829e487b56754b6e380"
PV = "2022.12+git${SRCPV}"
