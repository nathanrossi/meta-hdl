require liteeth.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=d5fe6a63c47e2580771cc56883d2ed64"

SRCREV = "b96a6252c4b6172a597002cd861ffe0f94d9b130"
PV = "2024.08+git${SRCPV}"
