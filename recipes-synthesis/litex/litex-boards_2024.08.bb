require litex-boards.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=44c881049d568ad42c4c81ed51fa6515"

SRCREV = "7f3ee12c3da37a67481b41192cdc9a9f15626cc7"
PV = "2024.08+git${SRCPV}"
