require litesdcard.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=9f3746ccc6348e52617a7a527ae22ff8"

SRCREV = "e37e62f0178e18873127cff1853f30f694358cf4"
PV = "2024.08+git${SRCPV}"
