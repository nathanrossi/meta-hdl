require litex-pythondata-cpu-vexriscv-smp.inc

SRCREV = "de5cf008d5c7ad696177956ff57464231a07f0b5"
PV = "2023.08+git${SRCPV}"
