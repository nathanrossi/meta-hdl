require litedram.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=f9889f63ba517bd604fde468a6b85bfd"

SRCREV = "3b2bcf91ede26b8ef1e7bc98282cdd25f8757135"
PV = "2022.12+git${SRCPV}"
