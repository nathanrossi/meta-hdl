require litex-pythondata-cpu-vexriscv-smp.inc

SRCREV = "0a97182aff60dd830d04f8e10b042ecd99638fa3"
PV = "2024.08+git${SRCPV}"
