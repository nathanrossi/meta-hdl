require litesata.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=06961f9174ef2f11bff41b45f906eb5f"

SRCREV = "27f483776cd25e10e93a12dc6cf63866f35df045"
PV = "2023.08+git${SRCPV}"
