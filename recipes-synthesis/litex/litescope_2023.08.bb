require litescope.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=c779474112984b3fbcfaba3dc8f3f3b4"

SRCREV = "4d2df690af29562800f9e8f069648392f547ce89"
PV = "2023.08+git${SRCPV}"
