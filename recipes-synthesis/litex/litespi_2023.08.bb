require litespi.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=99cb24c95072af16a66df894e8b495b9"

SRCREV = "52d62063237fc2985f850ed4f2f48a3f65ca0437"
PV = "2023.08+git${SRCPV}"
