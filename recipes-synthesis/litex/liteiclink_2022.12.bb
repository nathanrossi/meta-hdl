require liteiclink.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=75a811b254c8b0477ed1864f5703e846"

SRCREV = "9a019a37baa60474dbed6b73c7876e8b7daedf33"
PV = "2022.12+git${SRCPV}"
