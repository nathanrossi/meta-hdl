require litedram.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=f9889f63ba517bd604fde468a6b85bfd"

SRCREV = "e96710f0dd0d0137969f044c16f261c1abcbfee1"
PV = "2024.08+git${SRCPV}"
