require litespi.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=99cb24c95072af16a66df894e8b495b9"

SRCREV = "63c815fe7c0c28b132a2407d836b7d8f80ea7a61"
PV = "2022.12+git${SRCPV}"
