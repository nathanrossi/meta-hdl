require litepcie.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=26002bebf4fb75e22401233046399ea1"

SRCREV = "ec6c7b8821012b8c8cd263305adc0c0eb8cea3f5"
PV = "2023.08+git${SRCPV}"
