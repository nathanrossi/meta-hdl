require litescope.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=c779474112984b3fbcfaba3dc8f3f3b4"

SRCREV = "eb745d73583ee2f81530acdea8761a40860ce216"
PV = "2024.08+git${SRCPV}"
