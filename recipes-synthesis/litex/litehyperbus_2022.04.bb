require litehyperbus.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=e40877df301ec6de075d51f4b7571d62"

SRCREV = "1cde460f24e06e30be7ac1cd361bb2d263528253"
PV = "2022.04+git${SRCPV}"
