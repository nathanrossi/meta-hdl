require liteiclink.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=75a811b254c8b0477ed1864f5703e846"

SRCREV = "e48140dd7ade2acaff4685d4c49a89553cd30312"
PV = "2023.08+git${SRCPV}"
