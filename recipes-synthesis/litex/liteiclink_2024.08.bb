require liteiclink.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=75a811b254c8b0477ed1864f5703e846"

SRCREV = "04ed5a38f6ca507740dbf7aeb68539308a1848f6"
PV = "2024.08+git${SRCPV}"
