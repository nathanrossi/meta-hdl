require litesata.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=06961f9174ef2f11bff41b45f906eb5f"

SRCREV = "6b6e45bf417ce1fc3b658d5af23371cc85b5ff06"
PV = "2022.12+git${SRCPV}"
