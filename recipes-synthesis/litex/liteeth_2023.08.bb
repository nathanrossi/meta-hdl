require liteeth.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=d5fe6a63c47e2580771cc56883d2ed64"

SRCREV = "a6775fe1aff9e3435c93c0b9f611bc27aeb05a37"
PV = "2023.08+git${SRCPV}"
