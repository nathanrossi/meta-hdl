require litex-boards.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=44c881049d568ad42c4c81ed51fa6515"

SRCREV = "a0b7811c54686d7ca47b73abbb2e4bfc0067b714"
PV = "2023.08+git${SRCPV}"
