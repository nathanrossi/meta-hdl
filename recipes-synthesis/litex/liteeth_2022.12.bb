require liteeth.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=d5fe6a63c47e2580771cc56883d2ed64"

SRCREV = "97dccdb294fa2081536f26f4ef6235c004007432"
PV = "2022.12+git${SRCPV}"
