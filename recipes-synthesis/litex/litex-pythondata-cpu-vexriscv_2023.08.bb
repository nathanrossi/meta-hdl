require litex-pythondata-cpu-vexriscv.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=38aa75cf4c4c87f018227d5ec9638d75"

SRCREV = "a36d99eeea984c261e16b744fc1d287c81099777"
PV = "2023.08+git${SRCPV}"
