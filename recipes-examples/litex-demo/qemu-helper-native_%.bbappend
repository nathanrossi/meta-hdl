RDEPENDS_${PN} += "qemu-litex-native"
DEPENDS += "qemu-litex-native"
