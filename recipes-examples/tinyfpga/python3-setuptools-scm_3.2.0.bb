inherit setuptools3
require recipes-devtools/python/python-setuptools-scm.inc

SRC_URI[md5sum] = "178e4e7b14c163e0e77ae7ec6684cc0f"
SRC_URI[sha256sum] = "52ab47715fa0fc7d8e6cd15168d1a69ba995feb1505131c3e814eb7087b57358"

BBCLASSEXTEND += "nativesdk"
