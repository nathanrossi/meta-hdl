GLIBC_GIT_URI_riscv32 = "git://github.com/alistair23/glibc;protocol=https"
SRCBRANCH_riscv32 = "alistair/rv32.rfc5"
SRCREV_glibc_riscv32 = "1fe4adcab0084df29f4c18c2d5f1154a1eeb119d"
