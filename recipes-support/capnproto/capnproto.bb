require recipes-devtools/capnproto/capnproto_0.7.0.bb

SRC_URI = "git://github.com/capnproto/capnproto;protocol=https"
SRCREV = "12081037fb9a9ca5afe5eb3fe2c55187da59ee64"
PV = "v0.7.0+git${SRCPV}"

